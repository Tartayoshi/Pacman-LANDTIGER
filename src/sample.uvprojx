# Keil uVision project sample.uvprojx, settings and files
target LandTiger_LPC1768 (release) (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample_GLCD_TP
  c flags: Optim=2 v6Lang=5 v6LangP=3
  c include: .\Source;.\Source\CMSIS_core;.\Source\GLCD;.\Source\timer;.\Source\button_EXINT;.\Source\TouchPanel
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./Source/: startup_LPC17xx.s
  group main
    ./Source/: sample.c
  group lib_SoC_board
    ./Source/: system_LPC17xx.c
  group timer
    ./Source/timer/: IRQ_timer.c lib_timer.c timer.h
  group GLCD
    ./Source/GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h HzLib.c HzLib.h
  group CMSIS_core
    ./Source/CMSIS_core/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm3.h mpu_armv7.h
  group joystick
    ./Source/joystick/: funct_joystick.c joystick.h lib_joystick.c
  group Pacman
    ./Source/Pacman/: gameEngine.c gameEngine.h player.c player.h map.c map.h mapData.c mapData.h gui.h gui.c utility.h bitmapData.c bitmapData.h ghost.h ghost.c
  group RIT
    ./Source/RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group Button
    ./Source/button_EXINT/: button.h IRQ_button.c lib_button.c
  group Bitmap
    ./Source/Bitmap/: bitmap.h bitmap.c
  group music
    ./Source/music/: music.c music.h musicData.h
  group Random
    ./Source/random/: random.c random.h
  group CAN
    ./Source/CAN/: CAN.h IRQ_CAN.c lib_CAN.c
target SW_DEBUG (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: sample_GLCD_TP
  c flags: Optim=2 v6Lang=5 v6LangP=3
  c define: SIMULATOR
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 6.1.0
